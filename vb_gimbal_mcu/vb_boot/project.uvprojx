# Keil uVision project project.uvprojx, settings and files
target Project (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: HC32F460JETA HDSC
  pack: HDSC.HC32F460.1.0.7
  cpu: IRAM(0x1FFF8000,0x2F000) IRAM2(0x200F0000,0x1000) IROM(0x00000000,0x80000) IROM2(0x03000C00,0x003FC) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project +hex
  AfterMake: fromelf.exe --bincombined -o ./Objects/Update.bin ./Objects/*.axf
  AfterMake: copy.bat
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: HC32F460,USE_DEVICE_DRIVER_LIB
  c misc: --diag_suppress=186,66
  c include: .\Libraries\inc;.\Libraries\device;.\Libraries\core;.\Drivers;.\Device;.\User
  library: MicroLIB
  memory RVCT4: ROM 0x4000 size 0x8000
  memory RVCT5: ROM 0x3000c00 size 0x3fc
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x200f0000 size 0x1000
  scatter file: .\project.sct
  link misc: --keep=*Handler
  group User
    ./User/: App.c fifo.c init.c crc.c tiny_os.c message.c include.h ddl_config.h state_machine.c
    ./Libraries/src/: hc32f460_interrupts.c
  group Device
    ./Device/: dev_uart.c
  group Drivers
    ./Drivers/: drv_systick.c drv_flash.c drv_uart.c
  group MDK-ARM
    ./Libraries/device/: startup_hc32f460.s
  group CMSIS
    ./Libraries/device/: system_hc32f460.c
  group Libraries
    ./Libraries/src/: hc32f460_icg.c hc32f460_clk.c hc32f460_efm.c hc32f460_sram.c hc32f460_utility.c hc32f460_pwc.c hc32f460_timer0.c hc32f460_usart.c hc32f460_dmac.c hc32f460_gpio.c hc32f460_swdt.c
