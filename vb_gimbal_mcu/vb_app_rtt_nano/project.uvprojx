# Keil uVision project project.uvprojx, settings and files
target Project (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: HC32F460JETA HDSC
  pack: HDSC.HC32F460.1.0.7
  cpu: IRAM(0x1FFF8000,0x2F000) IRAM2(0x200F0000,0x1000) IROM(0x00000000,0x80000) IROM2(0x03000C00,0x003FC) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project +hex
  AfterMake: fromelf.exe --bincombined -o ./Objects/Update.bin ./Objects/*.axf
  AfterMake: copy.bat
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: HC32F460,USE_DEVICE_DRIVER_LIB
  c misc: --diag_suppress=186,66
  c include: .\Libraries\inc;.\Libraries\device;.\Libraries\core;.\Drivers;.\Device;.\User;.\rtthread;.\rtthread\include;.\Components\finsh;.\Components\ulog;.\Components\ulog\syslog;.\Components\cpu_usage;.\Components\perf_counter;.\Components\utest
  library: MicroLIB
  memory RVCT4: ROM 0xc000 size 0x32000
  memory RVCT5: ROM 0x3000c00 size 0x3fc
  memory RVCT9: RAM 0x20008000 size 0x1f000
  memory RVCT10: RAM 0x200f0000 size 0x1000
  scatter file: .\project.sct
  link misc: --keep=*Handler
  group User
    ./User/: App.c include.h high_speed.c vb_utest_api_tc.c vb_utest_api_tc2.c msp.c fifo.c crc.c ddl_config.h state_machine.c
    ./Libraries/src/: hc32f460_interrupts.c
  group Device
    ./Device/: dev_uart.c
  group Drivers
    ./Drivers/: drv_systick.c drv_flash.c drv_uart.c
  group MDK-ARM
    ./Libraries/device/: startup_hc32f460.s
  group CMSIS
    ./Libraries/device/: system_hc32f460.c
  group Libraries
    ./Libraries/src/: hc32f460_icg.c hc32f460_clk.c hc32f460_efm.c hc32f460_sram.c hc32f460_utility.c hc32f460_pwc.c hc32f460_timer0.c hc32f460_timera.c hc32f460_usart.c hc32f460_dmac.c hc32f460_gpio.c hc32f460_swdt.c
  group rtthread
    ./rtthread/: rtconfig.h board.c
    ./rtthread/src/: thread.c clock.c components.c cpu.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c slab.c timer.c
    ./rtthread/libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
  group finsh
    ./Components/finsh/: finsh_port.c cmd.c msh.c shell.c
  group ulog
    ./Components/ulog/: ulog.c ulog_def.h
    ./Components/ulog/backend/: console_be.c
  group cpu_usage
    ./Components/cpu_usage/: cpu_usage.c
  group perf_counter
    ./Components/perf_counter/: perf_counter.c perf_port.c perf_port.h
  group utest
    ./Components/utest/: utest.c
