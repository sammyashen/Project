# Keil uVision project project.uvprojx, settings and files
target Project (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: N32L406CB Nationstech
  pack: Nationstech.N32L40x_DFP.0.1.0
  cpu: IRAM(0x20000000,0x6000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project +hex
  AfterMake: fromelf.exe --bincombined -o ./Objects/Update.bin ./Objects/*.axf
  AfterMake: copy.bat
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,N32L40X
  c include: .\Libraries\core;.\Libraries\device;.\Libraries\inc;.\Device;.\Drivers;.\User;.\Components\letter_shell\port;.\Components\letter_shell\src;.\Components\breo_iap;.\Components\cm_backtrace;.\Components\cm_backtrace\Languages\en-US;.\Components\cm_backtrace\Languages\zh-CN
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x6000
  group User
    ./User/: App.c init.c fifo.c pid.c topic.c mass.c tiny_os.c n32l40x_it.c state_machine.c debug.c
  group Devices
    ./Device/: dev_uart.c dev_buzzer.c dev_led.c dev_ble.c dev_heat.c dev_motor.c
  group Drivers
    ./Drivers/: drv_sysclk.c drv_gpio.c drv_uart.c drv_adc.c drv_key.c drv_pwm.c
  group breo_iap
    ./Components/breo_iap/: af_port.c af_utils.c iap.c ymodem.c bsp.c iap_addr_def.h
  group letter_shell
    ./Components/letter_shell/port/: shell_port.c
    ./Components/letter_shell/src/: shell.c shell_cmd_list.c shell_ext.c
  group MDK-ARM
    ./Libraries/device/startup/: startup_n32l40x.s
  group Librarise
    ./Libraries/src/: misc.c n32l40x_flash.c n32l40x_rcc.c n32l40x_gpio.c n32l40x_pwr.c n32l40x_adc.c n32l40x_iwdg.c n32l40x_tim.c n32l40x_usart.c n32l40x_dma.c
  group CMSIS
    ./Libraries/device/: system_n32l40x.c
