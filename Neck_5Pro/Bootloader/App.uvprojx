# Keil uVision project App.uvprojx, settings and files
target Project (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: N32G452RCL7 Nationstech
  pack: Nationstech.N32G45x_DFP.1.0.1
  cpu: IRAM(0x20000000,0x24000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Bootloader +hex
  AfterMake: fromelf.exe --bincombined -o ./Objects/bootloader.bin ./Objects/*.axf
  AfterMake: copy.bat
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,N32G45X
  c include: .\Libraries\core;.\Libraries\device;.\Libraries\inc;.\User;.\Drives;.\rtthread;.\rtthread\include;.\Module;.\Device
  memory RVCT4: ROM 0x8000000 size 0x2800
  memory RVCT9: RAM 0x20000000 size 0x24000
  group User
    ./User/: App.c n32g45x_it.c include.h
  group Drives
    ./Drives/: dri_sysclk.c dri_flash.c
  group MDK-ARM
    ./Libraries/device/startup/: startup_n32g45x.s
  group Libraries
    ./Libraries/src/: misc.c n32g45x_flash.c n32g45x_pwr.c n32g45x_rcc.c
  group CMSIS
    ./Libraries/device/: system_n32g45x.c
