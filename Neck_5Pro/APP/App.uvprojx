# Keil uVision project App.uvprojx, settings and files
target Project (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: N32G452RCL7 Nationstech
  pack: Nationstech.N32G45x_DFP.1.0.1
  cpu: IRAM(0x20000000,0x24000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: App +hex
  AfterMake: fromelf.exe --bincombined -o ./Objects/Update.bin ./Objects/*.axf
  AfterMake: copy.bat
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,N32G45X
  c include: .\Libraries\core;.\Libraries\device;.\Libraries\inc;.\User;.\rtthread;.\rtthread\include;.\Device;.\Driver;.\Components\finsh;.\Components\fal\inc;.\Components\fal\port;.\Components\easyflash\inc;.\Components\easyflash\port;.\Components\breo_esp_protocol\port;.\Components\breo_esp_protocol\src;.\Components\breo_app_protocol\port;.\Components\breo_app_protocol\src;.\Components\yemodem
  memory RVCT4: ROM 0x8002800 size 0x19000
  memory RVCT9: RAM 0x20000000 size 0x24000
  group User
    ./User/: App.c include.h init.c fifo.c device.c topic.c n32g45x_it.c pid.c debug.c
  group Device
    ./Device/: dev_uart.c dev_adc.c dev_mp.c dev_buzzer.c dev_led.c dev_heat.c dev_motor.c dev_ble.c
  group Driver
    ./Driver/: drv_gpio.c drv_key.c drv_uart.c drv_sf_i2c_led.c drv_sf_i2c_mp.c drv_sysclk.c drv_pwm.c drv_adc.c drv_motor_fg.c
  group fal
    ./Components/fal/port/: fal_flash_n32g45x_port.c fal_cfg.h
    ./Components/fal/src/: fal.c fal_flash.c fal_partition.c fal_rtt.c
  group easyflash
    ./Components/easyflash/port/: ef_port.c
    ./Components/easyflash/inc/: ef_cfg.h
    ./Components/easyflash/src/: easyflash.c ef_env.c ef_log.c ef_utils.c
  group finsh
    ./Components/finsh/: finsh_port.c cmd.c msh.c shell.c
  group ymodem
    ./Components/yemodem/: ymodem.c
  group breo_esp_protocol
    ./Components/breo_esp_protocol/port/: esp_protocol_prot.c
    ./Components/breo_esp_protocol/src/: esp_protocol.c
  group breo_app_protocol
    ./Components/breo_app_protocol/port/: app_protocol_prot.c
    ./Components/breo_app_protocol/src/: app_protocol.c
  group rtthread
    ./rtthread/: rtconfig.h board.c
    ./rtthread/src/: thread.c clock.c components.c cpu.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c slab.c timer.c
    ./rtthread/libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
  group MDK-ARM
    ./Libraries/device/startup/: startup_n32g45x.s
  group Libraries
    ./Libraries/src/: misc.c n32g45x_adc.c n32g45x_crc.c n32g45x_dma.c n32g45x_flash.c n32g45x_gpio.c n32g45x_i2c.c n32g45x_pwr.c n32g45x_rcc.c n32g45x_spi.c n32g45x_tim.c n32g45x_usart.c n32g45x_iwdg.c n32g45x_exti.c n32g45x_dbg.c
  group CMSIS
    ./Libraries/device/: system_n32g45x.c
