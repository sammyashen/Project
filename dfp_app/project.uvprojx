# Keil uVision project project.uvprojx, settings and files
target Project (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: N32L406CB Nationstech
  pack: Nationstech.N32L40x_DFP.0.1.0
  cpu: IRAM(0x20000000,0x6000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project +hex
  AfterMake: fromelf.exe --bincombined -o ./Objects/Update.bin ./Objects/*.axf
  AfterMake: copy.bat
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,N32L40X
  c misc: --diag_suppress=186,66
  c include: .\Libraries\inc;.\Libraries\device;.\Libraries\core;.\Device;.\DeviceDrivers;.\rtthread;.\rtthread\include;.\rtthread\include\libc;.\User;.\Components\finsh;.\Components\utils;.\Components\cpu_usage;.\Components\perf_counter
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x6000
  scatter file: .\project.sct
  link misc: --keep=*Handler
  group User
    ./User/: App.c include.h
  group Device
    ./Device/: dev_uart.c dev_adc.c dev_imu.c
  group DeviceDrivers
    ./DeviceDrivers/: drv_systick.c drv_uart.c drv_gpio.c drv_adc.c drv_pwm.c drv_dac.c drv_hw_spi.c drv_hw_i2c.c drv_flash.c
  group MDK-ARM
    ./Libraries/device/startup/: startup_n32l40x.s
  group CMSIS
    ./Libraries/device/: system_n32l40x.c
  group Libraries
    ./Libraries/src/: misc.c n32l40x_it.c n32l40x_adc.c n32l40x_dac.c n32l40x_dma.c n32l40x_gpio.c n32l40x_i2c.c n32l40x_pwr.c n32l40x_rcc.c n32l40x_spi.c n32l40x_tim.c n32l40x_usart.c n32l40x_flash.c n32l40x_exti.c
  group rtthread
    ./rtthread/: board.c rtconfig.h
    ./rtthread/src/: clock.c components.c cpu.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c slab.c thread.c timer.c
    ./rtthread/libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
  group finsh
    ./Components/finsh/: finsh_port.c cmd.c msh.c shell.c
  group utils
    ./Components/utils/: fifo.c tiny_dev.c topic.c state_machine.c user_misc.c
  group cpu_usage
    ./Components/cpu_usage/: cpu_usage.c
  group perf_counter
    ./Components/perf_counter/: perf_port.c perf_port.h perf_counter.c
